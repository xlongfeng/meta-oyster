# Copyright (C) 2020 Landon Hsiao <xlongfeng@126.com>.

CORE_IMAGE_BASE_INSTALL_append = " libiio libiio-tests"
CORE_IMAGE_BASE_INSTALL_append = " gstreamer1.0-plugins-base gstreamer1.0-plugins-good gstreamer1.0-plugins-bad"
