# Append path for oyster layer to include bsp pointercal.xinput
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
