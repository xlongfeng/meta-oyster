# Copyright (C) 2020 Landon Hsiao <xlongfeng@126.com>.

CORE_IMAGE_BASE_INSTALL_append = " inputattach inputattach-daemon"
