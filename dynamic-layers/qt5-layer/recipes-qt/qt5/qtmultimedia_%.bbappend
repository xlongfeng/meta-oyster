# Copyright (C) 2020 Landon Hsiao <xlongfeng@126.com>.

PACKAGECONFIG_append = " gstreamer"
